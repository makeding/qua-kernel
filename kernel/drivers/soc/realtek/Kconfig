## kernel/drivers/soc/realtek/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config RTD129X_RBUS_GUARD
	bool
	depends on ARCH_REALTEK
```
